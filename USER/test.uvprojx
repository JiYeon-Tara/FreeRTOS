# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\BSP\KEY;..\BSP\LED;..\CORE;..\LIB;..\BOARD_PERIPHERAL\EXTI;..\BOARD_PERIPHERAL\KEY;..\BOARD_PERIPHERAL\LED;..\BOARD_PERIPHERAL\TIMER;..\BOARD_PERIPHERAL\WDT;..\BSP\LCD;..\BSP\OLED;..\BSP\TEMP_18B20;..\BSP\TP;..\Service\BT;..\Service\USART;..\BOARD_PERIPHERAL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group BSP
    ../BSP/LCD/: ILI9341.c
    ../BSP/TEMP_18B20/: 18b20.c
  group CORE
    ./: startup_stm32f10x_hd.s
  group BOARD_PERIPHERAL
    ../BOARD_PERIPHERAL/EXTI/: exti.c
    ../BOARD_PERIPHERAL/KEY/: key.c
    ../BOARD_PERIPHERAL/LED/: led.c
    ../BOARD_PERIPHERAL/TIMER/: timer.c
    ../BOARD_PERIPHERAL/WDT/: watch_dog_timer.c
  group Service
    ../Service/BT/: service_bt.c
    ../Service/USART/: serviec_usart.c
