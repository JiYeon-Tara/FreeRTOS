# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Target +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\BSP\LED;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\0_task;..\..\STM32F10x_FWLib\inc;..\..\CORE;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Thread;..\..\BOARD_PERIPHERAL\TIMER;..\..\BOARD_PERIPHERAL\USART;..\..\BSP\LCD;..\..\BSP\KEY;..\..\BOARD_PERIPHERAL\EXTI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c start_up.c
  group BSP
    ../../BSP/LED/: led.c
    ../../BSP/KEY/: key.c
    ../../BSP/LCD/: lcd.c
  group BOARD_PERIPHERAL
    ../../BOARD_PERIPHERAL/TIMER/: my_timer.c timer.c
    ../../BOARD_PERIPHERAL/USART/: my_usart.c
    ../../BOARD_PERIPHERAL/EXTI/: exti.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Thread
    ../../Thread/: led0_thread.c led1_thread.c thread_manager.c thread_monitor.c interrupt_thread.c thread_ui.c thread_algo.c thread_key.c thread_dual_comm.c
